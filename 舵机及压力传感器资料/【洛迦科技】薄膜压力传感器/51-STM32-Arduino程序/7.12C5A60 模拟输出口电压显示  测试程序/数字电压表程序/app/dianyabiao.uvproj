# Keil uVision project dianyabiao.uvproj, settings and files
target dianyabiao (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: dianyabiao +hex
  c flags: Optimize=8 SizeSpeed=1
  group app
    ./: dianyabiao.c
  group output
    ./: dianyabiao.c
